# Keil uVision project E80.uvprojx, settings and files
target E80 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: E80 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Radio/lr11xx_driver/src;../Radio/radio_hal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c user_uart.c fifo.c event.c user_radio.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Radio/Driver
    ../Radio/lr11xx_driver/src/: lr_fhss_v1_base_types.h lr11xx_bootloader.c lr11xx_bootloader.h lr11xx_bootloader_types.h lr11xx_crypto_engine.c lr11xx_crypto_engine.h lr11xx_crypto_engine_types.h lr11xx_driver_version.c lr11xx_driver_version.h lr11xx_gnss.c lr11xx_gnss.h lr11xx_gnss_types.h lr11xx_hal.h lr11xx_lr_fhss.c lr11xx_lr_fhss.h lr11xx_lr_fhss_types.h lr11xx_radio.c lr11xx_radio.h lr11xx_radio_timings.c lr11xx_radio_timings.h lr11xx_radio_types.h lr11xx_regmem.c lr11xx_regmem.h lr11xx_rttof.c lr11xx_rttof.h lr11xx_rttof_types.h lr11xx_system.c lr11xx_system.h lr11xx_system_types.h lr11xx_types.h lr11xx_wifi.c lr11xx_wifi.h lr11xx_wifi_types.h
  group Radio/Hal
    ../Radio/radio_hal/: lr11xx_hal.c lr11xx_pa_pwr_cfg.h radio_utilities.c radio_utilities.h
software components: CMSIS:CORE 5.4.0
